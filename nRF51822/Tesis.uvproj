# Keil uVision project Tesis.uvproj, settings and files
target nRF51822AA (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: nRF51xxx Nordic Semiconductor
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x4000) CPUTYPE("Cortex-M0") CLOCK(16000000) ELITTLE
  output: Tesis +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: __CORTEX_M0,  TARGET_MCU_NRF51_16K,  TARGET_MCU_NRF51822,  TARGET_NRF51822_MKIT,  NRF51,  TARGET_CORTEX_M,  TARGET_NRF51822,  ARM_MATH_CM0,  TOOLCHAIN_ARM_STD,  __MBED__=1,  TARGET_NORDIC,  TARGET_MCU_NRF51,  TARGET_MCU_NORDIC_16K,  TARGET_M0,  MBED_BUILD_TIMESTAMP=1450168836.22,  TOOLCHAIN_ARM,  TARGET_MCU_NRF51_16K_S130,  __ASSERT_MSG,
  c misc: --gnu --no_rtti
  c include: .;  BLE_API;  BLE_API/common;  BLE_API/public;  BLE_API/services;  nRF51822;  nRF51822/btle;  nRF51822/btle/custom;  nRF51822/common;  nRF51822/nordic;  nRF51822/nordic/nrf-sdk;  nRF51822/nordic/nrf-sdk/app_common;  nRF51822/nordic/nrf-sdk/ble;  nRF51822/nordic/nrf-sdk/ble/ble_services;  nRF51822/nordic/nrf-sdk/ble/device_manager;  nRF51822/nordic/nrf-sdk/bootloader_dfu;  nRF51822/nordic/nrf-sdk/s110;  nRF51822/nordic/nrf-sdk/sd_common;  nRF51822/nordic/app_common;  nRF51822/nordic/bootloader_dfu;  nRF51822/nordic/ble;  nRF51822/nordic/ble/ble_services;  mbed;  mbed/TARGET_NRF51822;  mbed/TARGET_NRF51822/TARGET_NORDIC;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nrf-sdk;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nrf-sdk/app_common;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/nrf-sdk/sd_common;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_7_1_0;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_7_1_0/s110_nrf51822_7.1.0_API;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/Lib/s110_nrf51822_7_1_0/s110_nrf51822_7.1.0_API/include;  mbed/TARGET_NRF51822/TARGET_NORDIC/TARGET_MCU_NRF51822/TARGET_NRF51822_MKIT;  mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/nRF51822.sct
  link misc: mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/board.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/retarget.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/startup_nRF51822.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/sys.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/system_nrf51822.o
            
              mbed/TARGET_NRF51822/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    nRF51822/nordic/app_common/: app_gpiote.c app_scheduler.c hci_mem_pool.c crc16.cpp pstorage.cpp
    nRF51822/nordic/bootloader_dfu/: bootloader_util_arm.c dfu_app_handler.c
    ./: main.cpp
    BLE_API/common/: BLEDevice.cpp GapAdvertisingData.cpp GapAdvertisingParams.cpp GattService.cpp UUID.cpp
    BLE_API/services/: DFUService.cpp UARTService.cpp
    nRF51822/: nRF51822n.cpp nRF51Gap.cpp nRF51GattServer.cpp
    nRF51822/btle/: btle.cpp btle_advertising.cpp btle_gap.cpp
    nRF51822/btle/custom/: custom_helper.cpp
    nRF51822/nordic/: softdevice_handler.cpp
    nRF51822/nordic/ble/: ble_advdata.cpp ble_advdata_parser.cpp ble_bondmngr.cpp ble_conn_params.cpp ble_debug_assert_handler.cpp ble_error_log.cpp
    nRF51822/nordic/ble/ble_services/: ble_srv_common.cpp
